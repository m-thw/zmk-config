## boards/shields/Shapekey_test/Kconfig.defconfig
```kconfig
if SHIELD_SHAPEKEY_TEST

config ZMK_KEYBOARD_NAME
    default "shapekey_test"

endif
```
